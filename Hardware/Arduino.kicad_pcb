# Repository BEMNETADEFIS/Aruduino-Breakout-Board-for-Universal-Base-board-BOB-11016

## KiCad design Hardware/Arduino.kicad_pcb

Parts:
C1, C2: 22pF
C3: 100nF
D1, D2, D3, D4: LED
IC1: ATMEGA8-P; DIL28
JP1: JUMPER
P1: CONN_5X2
P2, P3, P4, P5: CONN_10
P6: CONN_7
R1, R3, R4, R5: 1k
R2: 10k
SW1: SPST
X1: CRYSTAL

Connections:
/2: IC1.4 ((INT0)PD2), P5.8
/3: IC1.5 ((INT1)PD3), P5.7
/4: IC1.6 ((XCK/T0)PD4), P5.6
/5: IC1.11 ((T1)PD5), P5.5
/6: IC1.12 ((AIN0)PD6), P5.4
/7: IC1.13 ((AIN1)PD7), P5.3
/8: IC1.14 ((ICP)PB0), P5.2
/9: IC1.15 ((OC1A)PB1), P5.1
/10: IC1.16 ((~SS~/OC1B)PB2), P4.10
/11: IC1.17 ((MOSI/OC2)PB3), P1.1, P4.9
/12: IC1.18 ((MISO)PB4), P1.9, P4.8
/13: D4.1 (A), IC1.19 ((SCK)PB5), P1.7, P4.7
/A0: IC1.23 ((ADC0)PC0), P3.5
/A1: IC1.24 ((ADC1)PC1), P3.6
/A2: IC1.25 ((ADC2)PC2), P3.7
/A3: IC1.26 ((ADC3)PC3), P3.8
/AREF: C3.2, IC1.21 (AREF), P4.5
/RESET: IC1.1 (PC6(~RESET~)), P1.5, P3.2, R2.2, SW1.1; also elsewhere on the board
/RX: D2.1 (A), IC1.2 ((RXD)PD0), P2.1, P5.10, P6.4
/SCL: IC1.28 ((ADC5/SCL)PC5), P3.10, P4.3
/SDA: IC1.27 ((ADC4/SDA)PC4), P3.9, P4.4
/TX: D3.1 (A), IC1.3 ((TXD)PD1), P2.2, P5.9, P6.5
/VCC: D1.1 (A), IC1.7 (VCC), IC1.20 (AVCC), P1.2, P4.1, P6.3, R2.1
GND: C1.1, C2.1, C3.1, IC1.8 (GND), IC1.22 (AGND), P1.4, P1.6, P1.8, P1.10, P4.2, P4.6, P6.1, R1.2, R3.2, R4.2, R5.2, SW1.2
unnamed: C1.2, IC1.9 (PB6(XTAL1/TOSC1)), X1.2
unnamed: C2.2, IC1.10 (PB7(XTAL2/TOSC2)), X1.1
unnamed 26: P6.7; also elsewhere on the board
unnamed: D1.2 (K), R1.1
unnamed: D2.2 (K), R3.1
unnamed: D3.2 (K), R4.1
unnamed: D4.2 (K), R5.1

Notes on the sheet:
Controller
Connectors
Programmer Connector
LEDs
7 PIN CONNECTOR DTR JUMPER

Board: 2 copper layers, 40.0 x 75.0 mm, 23 parts (1 on the bottom side), 31 nets.

Other parts of the board:
C4: C; SM1206
LOGO: LOGO (2)

Their connections:
/RESET: C4.2; also elsewhere on the board
unnamed 26: C4.1; also elsewhere on the board

File Hardware/Arduino_BOM.xlsx:

Id | Designator | Package | Quantity | Designation | Supplier and ref
1 | P2,P3,P5,P4 | SIL-10 | 4 | CONN_10
2 | SW1 | SW_PB_2pin_xl | 1 | SPST
3 | R1,R3 | SM1206 | 2 | 1k
4 | D1,D2,D3 | SM1206 | 3 | LED
5 | R2 | SM1206 | 1 | 10k
6 | C2,C1 | SM1206 | 2 | 22pF
7 | C3 | SM1206 | 1 | 100nF
8 | X1 | HC-49V | 1 | CRYSTAL
9 | IC1 | DIP-28__300_ELL | 1 | ATMEGA8-P
10 | P1 | VASCH5x2 | 1 | CONN_5X2

## Commit log

2015-05-21 Added Files
2015-08-10 added new files
2015-08-18 added corrected files
2015-09-09 added capacitor
